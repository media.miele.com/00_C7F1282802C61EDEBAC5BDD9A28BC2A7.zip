Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 094ae649-3895-4398-972b-49ef4c3f1208, NumberOfSaves: 1]
File name: 0001
Time: 2024-03-18T07:36:50+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12520660_CN_DA9299WC_BLBO:28929970_CN_12520660_DA9299WC_BLBO, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Design_Alusilver, z_Miele_Design_Glass, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 28929970_CN_12520660_DA9299WC_BLBO; sets with these values: 2

# IfcDistributionPort, Port_352326_5
Description: Flow; FlowDirection: SOURCEANDSINK
